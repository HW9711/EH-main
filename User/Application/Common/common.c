//Common.c

#include "Common.h"

/* 公共字节处理函数和旧泵换算函数；CRC 表与通信协议配套，不是业务配置参数。 */

//CRC 高位字节值表
static uint8_t auchCRCHi[] = {
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,
0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81,
0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,
0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,
0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,
0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
0x40
};

//CRC低位字节值表
static uint8_t auchCRCLo[] = {
0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7, 0x05, 0xC5, 0xC4,
0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,
0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD,
0x1D, 0x1C, 0xDC, 0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32, 0x36, 0xF6, 0xF7,
0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,
0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE,
0x2E, 0x2F, 0xEF, 0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1, 0x63, 0xA3, 0xA2,
0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,
0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB,
0x7B, 0x7A, 0xBA, 0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0, 0x50, 0x90, 0x91,
0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,
0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88,
0x48, 0x49, 0x89, 0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83, 0x41, 0x81, 0x80,
0x40
};

/*
 * 函数功能：计算一段数据的 CRC16/MODBUS 校验值。
 * 输入参数：data 为待校验数据；Len 为字节数，调用方保证数据地址和长度有效。
 * 返回参数：16 位 CRC 值；发送时的高低字节顺序由具体协议决定。
 */
uint16_t Common_Crc16(uint8_t *data, uint16_t Len)
{
  uint8_t uchCRCHi = 0xFF;   //高CRC字节初始化
  uint8_t uchCRCLo = 0xFF;   //低CRC 字节初始化
  uint16_t uIndex = 0;       //CRC循环中的索引

  while (Len--)
  {
	  uIndex = uchCRCLo ^ *data++;
	  uchCRCLo = uchCRCHi ^ auchCRCHi[uIndex];
	  uchCRCHi = auchCRCLo[uIndex];
  }

  return ((uchCRCHi << 8) | uchCRCLo);
}

/*
 * 函数功能：把目标缓冲区的每个字节填成同一个值。
 * 输入参数：sdat 为要填入的字节值；tdat 为目标地址；num 为字节数，调用方保证空间足够。
 * 返回参数：实际处理的字节数，即 num。
 */
uint16_t Common_Memset(uint8_t sdat, uint8_t *tdat, uint16_t num)
{
  uint16_t i = 0;

  for (i = 0; i < num; i++)
  {
    tdat[i] = sdat;
  }

  return num;
}

/*
 * 函数功能：从前向后逐字节复制数据。
 * 输入参数：sdat 为源地址；tdat 为目标地址；num 为字节数。调用方保证地址、空间及重叠情况适合此复制方式。
 * 返回参数：实际复制的字节数，即 num。
 */
uint16_t Common_CopyData(uint8_t *sdat, uint8_t *tdat, uint16_t num)
{
  uint16_t i = 0;

  for (i = 0; i < num; i++)
  {
    tdat[i] = sdat[i];
  }

  return num;
}

/*
 * 函数功能：先给浮点值加 0.01，再取其在内存中的 32 位表示；不是把数值取整。
 * 输入参数：fdata 为单精度浮点数。
 * 返回参数：调整后浮点数的原始位数据，按当前小端存储方式组合成 uint32_t。
 */
uint32_t Common_FolatToHex(float fdata)
{
  float temp = fdata + 0.01f; /* 保留原函数的 0.01 修正；返回的不是原始 fdata 的位数据。 */
  uint8_t *tdata = (uint8_t*)(&temp); /* 读取浮点数在内存中的四个字节，不执行整数数值转换。 */

  return ((tdata[3] << 24) | (tdata[2] << 16) | (tdata[1] << 8) | tdata[0]);
}

/*
 * 函数功能：保留旧版泵流量换算；当前工程无调用，实际 A/B 泵换算在 pump_behavior_core.c 中。
 * 输入参数：NumFluid 为旧版流量设定值；is_Irrigate_FLAG 非 0 选择灌注公式，0 选择注水公式。
 * 返回参数：旧公式算出的整数控制值，不代表实测流量或实测转速。
 */
uint32_t Common_CurrentVelocity(float NumFluid,uint8_t is_Irrigate_FLAG)
{
	float temp = 0;
	uint32_t temp1 = 0;
	//  旧版分段公式只处理下方列出的区间，超过 70 的输入仍使用最后的 2.5 倍公式。
	//  temp1 = NumFluid / 0.37;
	//  temp = temp1 + temp1 * 0.23;
	temp=NumFluid;
	if (temp == 0) /* 流量为 0 时必须直接输出 0，避免停泵状态仍由标定公式产生非零转速。 */
	temp1 = 0;
	#ifdef WATER_UPTAKE
	else /* 吸水泵配置使用固定比例换算，保持该硬件版本原有的流量标定关系。 */
	{
		temp1=temp*42;
	}
	#else
	else /* 未定义 WATER_UPTAKE 时，按参数选择旧灌注或注水公式。 */
  {
		if(is_Irrigate_FLAG) /* 灌注泵沿用线性标定系数 0.58，不能套用注水泵的分段补偿。 */
		{
				temp1=(uint32_t )(temp*0.58f);//灌注
		}
		else /* 注水旧公式按输入区间分段计算；此处没有检查实际流量。 */
		{
			if(temp>65&&temp<=70) /* 输入大于 65 且不超过 70 时，使用这一段旧公式。 */
				temp1=(uint32_t )temp*(temp*0.02f+2.1f);//注水
			
				else if(temp>=45&&temp<=65) /* 输入 45~65 时，先减 10，再乘对应系数。 */
				temp1=(uint32_t )(temp-10)*(temp*0.02f+2.1f);
				
				else if(temp>=40&&temp<45) /* 输入不小于 40 且小于 45 时，先减 5，再乘对应系数。 */
				temp1=(uint32_t )(temp-5)*(temp*0.02f+2.1f);
				
				else if(temp>=30&&temp<40) /* 输入不小于 30 且小于 40 时，先减 3，再乘对应系数。 */
				temp1=(uint32_t )(temp-3)*(temp*0.02f+2.3f);
				
				else /* 其他输入按 2.5 倍计算；本函数不限制输入范围。 */
					temp1 = (uint32_t )(temp*2.5f);	
		}
		
//		   
//		if(temp<=29)
//		temp1 = (uint32_t )(temp*2.2);	
//		else
//			{
//				if(is_Irrigate_FLAG)
//				{
//					temp1=(uint32_t )(temp*0.58);//灌注 
//				}
//				else
//				{
//					
//					if(temp>65&&temp<=70)
//					temp1=(uint32_t )temp*(temp*0.02+2.1);//注水
//				  else if(temp>=45&&temp<=65)    
//					temp1=(uint32_t )(temp-10)*(temp*0.02+2.1);
//				  else if(temp>=40&&temp<45)
//					temp1=(uint32_t )(temp-5)*(temp*0.02+2.1);
//					else if(temp>=30&&temp<40)
//					temp1=(uint32_t )(temp-3)*(temp*0.02+2.1);
//				}
//		}
	}
	#endif
	return temp1;
}

//============================================================================
//============================================================================
/*
 * 函数功能：逐字节比较两段数据是否完全一致。
 * 输入参数：dat1、dat2 为待比较缓冲区；num 为需要比较的字节数。
 * 返回参数：1 表示全部字节相同，0 表示至少一个字节不同。
 */
uint8_t Common_CompareData (uint8_t *dat1, uint8_t *dat2, uint16_t num)
{
  uint8_t ret = 0;
  uint16_t i, j = 0;

  for (i = 0; i < num; i++)
  {
    if (dat1[i] == dat2[i]) /* 只累计相同字节，循环结束后由累计数判断整段数据是否完全一致。 */
      j++;
  }
	if (j == num) /* 相同字节数达到请求长度时才返回成功，任一字节不同都保持失败。 */
    ret = 1;
		return ret;
}
























