# Keil uVision project MainCtrlF413MXOs.uvprojx, settings and files
target MainCtrlF413MXOs (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F413VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MainCtrlF413MXOs +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F413xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/Application/include;../User/Data;../User/Peripheral/include;../User/UI/include;../User/Cola_os/inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c dma.c iwdg.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group User/Application
    ../User/Application/Beep/: beep.c
    ../User/Application/Common/: common.c
    ../User/Application/ConnectScan/: connectscan.c
    ../User/Application/DirCurrent/: dircurrent.c
    ../User/Application/DriveCtrl/: drivectrl.c
    ../User/Application/Encryption/: encryption.c
    ../User/Application/FootPedal/: footpedal.c
    ../User/Application/Handle/: handledata.c handlekey.c handlescan.c
    ../User/Application/Motor/: motor.c
    ../User/Application/MotorUartData/: motoruartdata.c
    ../User/Application/Pedal/: pedal.c
    ../User/Application/Pump/: pump.c
    ../User/Application/RadioFreq/: radiofreq.c
    ../User/Application/Screen/: screen.c
    ../User/Application/ScreenKey/: param.c screenkey.c
    ../User/Application/SplitType/: splittype.c
    ../User/Application/Src/: userparser.c
    ../User/Application/Warn/: warn.c
    ../User/Application/Led/: sysrunled.c led.c
    ../User/Application/SerialPortPro/: Serialportpro.c
    ../User/Application/DataHand/: datahand.c
  group User/Data
    ../User/Data/: data.c
  group User/Peripheral
    ../User/Peripheral/board/: board.c
    ../User/Peripheral/bus/: iic.c OneWireI.c OneWireII.c
    ../User/Peripheral/delay/: delay.c
    ../User/Peripheral/EEPROM/: eeprom.c
    ../User/Peripheral/flash/: flash.c
    ../User/Peripheral/iwdg/: iwdg.c
    ../User/Peripheral/lcd/: lcd.c
    ../User/Peripheral/uart/: uart1.c uart2.c uart3.c uart4.c uart5.c uart6.c uart7.c
  group User/UI
    ../User/UI/src/: UI_FootPedalCalibration.c UI_Main.c UI_ModelConfiguration.c UI_Password.c UI_Start.c
  group User/ColaOs
    ../User/Cola_os/src/: cola_os.c
  group User/Doc
    ../User/Doc/: Note.h
  group Middlewares/FreeRTOS
    ./: 
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.1.2
